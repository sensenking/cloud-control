# Keil uVision project device_speed_temp.uvproj, settings and files
target device_speed_temp (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: device_speed_temp +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source
  group Source Group 1
    ../Source/: Display.C main.c MOTORDRIVE.C PWM.c TM1638.c UART.C DS18B20.C HEATERDRIVE.C
